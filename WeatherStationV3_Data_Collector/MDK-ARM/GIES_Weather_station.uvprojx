# Keil uVision project GIES_Weather_station.uvprojx, settings and files
target GIES_Weather_station (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: GIES_Weather_station +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PLATFORM=SX12xxEiger,USE_HAL_DRIVER,STM32L051xx
  c include: ../Inc;                          ../Drivers/STM32L0xx_HAL_Driver/Inc;                          ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;                          ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;                          ../Drivers/CMSIS/Include;                          ..\SX1278\radio;                          ..\SX1278\platform\sx12xxEiger;                          ..\SX1278\platform;                          ..\SGP30
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: GIES_Weather_station\GIES_Weather_station.sct
  group Application/User
    ../Src/: sensors.c VEML6070.c bme680.c main.c gpio.c adc.c iwdg.c rtc.c spi.c usart.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/CMSIS
    ./: startup_stm32l051xx.s
    ..//Src/: system_stm32l0xx.c
  group SX1278
    ../SX1278/radio/: radio.c sx1232.c sx1232-Misc.c sx1272.c sx1272-Fsk.c sx1272-FskMisc.c sx1272-LoRa.c sx1272-LoRaMisc.c sx1276.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c
    ../SX1278/platform/sx12xxEiger/: spi_1278.c stm32fxxx_it.c sx12xxEiger.c sx1232-Hal.c sx1272-Hal.c sx1276-Hal.c
  group SGP30
    ../SGP30/: sensirion_common.c sensirion_sw_i2c.c sgp30.c sgp30_featureset.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c
software components: CMSIS:CORE 4.3.0
